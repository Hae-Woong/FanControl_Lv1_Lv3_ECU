<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00050.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="01C31FCF-2348-44B3-A7E2-37C1267D19C9">
      <SHORT-NAME>MICROSAR_MemMap</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="FC22520C-4212-4F3D-B4EA-6FAD1A9FF3C8">
          <SHORT-NAME>SwAddrMethods</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FE8638BA-6B96-49F6-A0C7-09F27FBBD909">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="F0B88BDB-AB1E-4070-B31B-5A29EF128891">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="40D539DE-4CBB-4E99-B53B-FA1A9DD677DA">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D2FE8A32-6F69-4626-A8D0-E454F8A9163F">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="577BC5FA-F7F8-4685-B364-7DF359FA5CEC">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ff55d029-386d-43a2-b3c2-dfef4c7a5e36">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="0d6f5530-90b3-408c-99b3-034d85894e77">
          <SHORT-NAME>BswM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="ff66fb4a-f401-4fa3-892c-2c6faa8afa4e">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="38d42423-88e2-4a5c-aa74-1917233a5249">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="b88688fa-7f84-4e16-b66a-40a980121f91">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="10c69b5c-672b-4932-8b12-74d2ccbd8c29">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="44b947ca-6a45-43f7-99a4-d759f964c716">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="e70201d7-a562-406c-a923-a03dab0a3d8c">
          <SHORT-NAME>ComM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="bb7cd120-1149-429f-8cea-ecba530aa7c8">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="f6a98691-9ff8-4efd-8c03-15f3fd207072">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="aad071eb-12e0-4807-9531-729c43bf8501">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="b62a5b35-f424-4d7b-a9b9-d0bf1ddc55b6">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="b27279ad-3615-4268-8226-0ab051adf72e">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8991F284-BF0D-4C05-BA7B-3CBAE12762B4">
      <SHORT-NAME>VectorAutosarExplorerGeneratedObjects</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="A6AFC2D4-22A0-4DE4-AF80-AAA3F863F055">
          <SHORT-NAME>SYSTEM</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8CEB929E-99EB-4DAC-9BD0-1FA1046FA2C2">
          <SHORT-NAME>Comfort</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C89FB312-63D7-4BCF-BC67-B2311E3D4526">
          <SHORT-NAME>ECU_INSTANCES</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2B35AC71-9CE7-44F7-9C5A-C37EC28CD6E1">
          <SHORT-NAME>FRAME</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F91775B8-2BBB-4FAD-BD0F-711AAD5C594C">
          <SHORT-NAME>PDUS</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6F58D853-DEA5-4D04-8F1A-585E48DF3A67">
          <SHORT-NAME>I_SIGNALS</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AE477164-64D5-48A9-ABDD-6B0CB94ECE0D">
          <SHORT-NAME>SYSTEM_SIGNALS</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BC4721AB-DDF7-438E-B588-195848A44309">
          <SHORT-NAME>PDU_GROUP</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8F4192DB-3836-42D3-BB23-69A562102F3B">
          <SHORT-NAME>UNIT</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B4A1259C-E9ED-491D-ACDA-823769F83FF0">
          <SHORT-NAME>BASE_TYPES</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D69D6546-5710-458F-BCE5-D96B6FA09788">
          <SHORT-NAME>COMPUMETHODS</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="5C4E8A16-1E2E-4C2C-9339-3E035511DC38">
          <SHORT-NAME>Diagnostic</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8BB770FF-33A8-4E6C-A055-2910ECA123A4">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="A8F77C11-6E0C-479D-80C2-92D690879F14">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FBCED4A7-767A-4328-8354-E4025E9EBD53">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E826F6B0-CB89-46D7-A54E-164ECBC6225D">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="7AF3321B-4A40-49D6-98B4-E91923E3A846">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0D177998-913C-46E8-9075-7EA05FA5B28D">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A58DF33E-6E4B-4340-95FC-DF587B02DA11">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="74F0D733-B383-409F-AA7C-E5CC2C52B438">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BEDBB50C-DD46-4730-B374-4611A55EC7A8">
      <SHORT-NAME>DataType</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="E2472275-05F2-4535-85FA-D980CE780641">
          <SHORT-NAME>Constraint</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7CAB9969-26B6-4F97-846C-09AFF591140C">
          <SHORT-NAME>Semantics</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3D507D0F-4B99-4957-8EDF-5203A0DD21E1">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C6AE16DD-8E78-427A-84E7-7F60ACBAE191">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2E784BBE-D819-42A8-A810-B311CDFAA7BD">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8DD521D9-A957-40A7-BD78-AD62DF86B7A1">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C29B03A5-24CC-46AC-BA8A-231F92690DC3">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="42CFC695-1860-4E96-88EB-B4F383D54F90">
      <SHORT-NAME>VehicleProject</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8E2C7DF0-4948-44D1-A3B1-6BBE811AA736">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="EB692657-EF1D-48A6-9FD2-DE94BED5192F">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BD107449-84F0-44C8-AD06-B81C552FABED">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F0F82DBD-1783-4E98-AA20-A5EEDAAFC7EC">
      <SHORT-NAME>NM</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DF90ACFA-9B71-4046-BDCE-143184CBD717">
      <SHORT-NAME>Cluster</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E892D965-E3EF-456F-85F1-FFD5646233E8">
      <SHORT-NAME>ECU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="48C40886-5586-4426-AA93-4B73D52CA48E">
      <SHORT-NAME>IPDUGroup</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D6D336B5-A2EC-40A5-8DCC-7882DEB303FA">
      <SHORT-NAME>CanFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C5B3F3FD-78FF-48D6-8833-122DA2B92C2C">
      <SHORT-NAME>PDU</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7FB03335-0553-4D64-88D8-4FB939BD9294">
      <SHORT-NAME>ISignal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="247B29C6-D679-4E42-A17E-660B18662E14">
      <SHORT-NAME>Signal</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1D8C7567-409A-4A56-8DC3-7841FF8D6CA3">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B49E6B74-5E95-48B0-84AB-DF13DB9A4AD7">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D7FF269E-050E-4B49-845A-BEF87B7967A6">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="942F99B8-B739-4E26-BC42-F5C0308202F6">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7F7BEF0A-8C62-4B1D-AFEC-C2DF53255ECF">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9592D442-66BE-47F4-A47D-B85D67F76E08">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="AAE597E1-2D5C-42C8-8E32-1A0DC26508A0">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="952A62B4-5557-42A1-9FC4-A43710F9AC6E">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="828903B5-4E65-4123-8E21-8A620124F26D">
      <SHORT-NAME>Diagnostics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7FE9912D-A90E-46E8-A123-5C4647C429CB">
      <SHORT-NAME>TP</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="40A451FF-66B1-46FD-9160-98C854EFD53E">
      <SHORT-NAME>Gateway</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="58D367CB-809D-44F6-85C0-CCAE2147B6E8">
      <SHORT-NAME>LinFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AACD71AD-F75F-41D9-B87E-99AEC0CFC74F">
      <SHORT-NAME>FlexrayFrame</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FA623333-6D17-4A8D-AB19-FDB82CBC0F67">
      <SHORT-NAME>DataTransformations</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A20AA08D-EAA3-42DE-91C2-B1571BB02C9F">
      <SHORT-NAME>SecureCommunicationPropsSet</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B9A0B9EB-3794-49A4-BBF5-DF327AB3DEA0">
      <SHORT-NAME>SWC</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B77A2648-38E5-41D1-813C-BDE8CBBAB73A">
      <SHORT-NAME>Constant</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>